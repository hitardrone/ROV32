# Keil uVision project rov_attitude.uvprojx, settings and files
target rov_attitude (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rov_attitude +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\User;..\Libraries\FWlib\inc;..\Sensors\ms5837;..\User\iic;..\User\usart1;..\User\usart3remap;..\Sensors\JY901;..\User\General_timx;..\User\Adanved_timx;..\Control\PID;..\User\systick;..\Control\loop
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../User/iic/: iic.c
    ../User/usart1/: usart1.c
    ../User/usart3remap/: usart3.c
    ../User/General_timx/: tim3.c
    ../User/Adanved_timx/: tim8.c
    ../User/systick/: systick.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CONTROL
    ../Control/PID/: PID.c
    ../Control/loop/: loop.c
  group SENSORS
    ../Sensors/ms5837/: ms5837.c
    ../Sensors/JY901/: JY901.c
  group DOC
    ../Doc/: readme.txt
